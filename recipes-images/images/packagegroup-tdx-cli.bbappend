# Remove btuart, as recipe is incompatible with read-only rootfs 
RRECOMMENDS_packagegroup-machine-tdx-cli_verdin-imx8mp_remove = "btuart"