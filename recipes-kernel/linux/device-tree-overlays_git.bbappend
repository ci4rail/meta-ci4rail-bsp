MACHINE_PREFIX_moducop-cpu01 = "verdin-imx8mm"
MACHINE_PREFIX_moducop-cpu01plus = "verdin-imx8mp"