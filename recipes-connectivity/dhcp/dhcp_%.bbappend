FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SYSTEMD_AUTO_ENABLE_${PN}-server = "enable"
