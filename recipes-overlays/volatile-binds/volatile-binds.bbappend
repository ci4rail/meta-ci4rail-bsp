VOLATILE_BINDS += " \
    /data/overlay-root  /root\n\
    /data/overlay-usr-snmp /usr/share/snmp\n\
"
