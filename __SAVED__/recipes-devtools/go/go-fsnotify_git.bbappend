# Branch with commit id referenced was renamed (from master) to main
SRC_URI = "git://${PKG_NAME}.git;branch=main"
